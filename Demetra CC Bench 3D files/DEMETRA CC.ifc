Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:41:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:41:10 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{7560FB2B-DE46-49F0-AE04-F93698BD9A28}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:41:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:41:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:41:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA CC:0PAAR163 - WITHOUT LEVELLING - VERDE ALPI:165029
In: 0 - Piano Terra
Type - Material: VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA CC
Type - Dati identità - BIM Name: DEMETRA CC SENZA SISTEMA DI LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR163; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-c/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-c/
Type - Dimensioni - Dimensions: 1705 mm x r 611 mm R 1211 mm x 480 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca modulare mod. “DEMETRA” CC costituita da una seduta monolitica. Copre un angolo di 90°, per completare la circonferenza servono 4 moduli."; Descrizione Tecnica per Codice: PANCA DEMETRA CC SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON PIANO DI SEDUTA BOCCIARDATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Modular bench mod. ""DEMETRA"" CC constituted by a monolithic seat. It covers a 90° angle, 4 modules are needed to complete the circumference."; Technical Description for Article: DEMETRA CC WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; MATERIALE SEDUTA: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone
Type - Meccanica - Weight ( kg): 944 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA CC: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA CC: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA CC: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA CC: 0PAAR163 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 2.701 m2; Volume: 0.383711 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
